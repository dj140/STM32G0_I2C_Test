# Keil uVision project STM32G031.uvprojx, settings and files
target STM32G031 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031G4Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G031 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G031xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\Lib;..\Drivers
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c i2c.c iwdg.c usart.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_pwr.c stm32g0xx_ll_usart.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group ArduinoAPI
    ../Lib/: Wire.cpp WireBase.cpp Arduino.c
  group Core
    ../Drivers/: gpio.c
software components: CMSIS:CORE 4.3.0
